# Keil uVision project RT-Thread.uvprojx, settings and files
target SWM330 (6160000::V6.16::ARMCLANG)
  device: SWM330xG Synwit
  pack: Synwit.SWM32_DFP.2.2.7
  cpu: CPUTYPE("Cortex-M33") DSP CLOCK(12000000) ESEL ELITTLE
  output: RT-Thread
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\SWM330_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM330_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM330_StdPeriph_Driver\CSL\SWM330_StdPeriph_Driver;.\APP;.\APP\rt-thread\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ./app/: main.c
    ./APP/: board.c
  group RT-Thread
    ./APP/rt-thread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group RT-Thread\Port
    ./APP/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group CSL\StdPD
    ../../SWM330_StdPeriph_Driver/CSL/SWM330_StdPeriph_Driver/: SWM330_adc.c SWM330_exti.c SWM330_gpio.c SWM330_i2c.c SWM330_pwm.c SWM330_timr.c SWM330_uart.c SWM330_wdt.c SWM330_dma.c SWM330_flash.c SWM330_port.c SWM330_spi.c SWM330_can.c SWM330_crc.c SWM330_lcd.c SWM330_rtc.c
  group CSL\CMSIS
    ../../SWM330_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM330.c
    ../../SWM330_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM330.s
