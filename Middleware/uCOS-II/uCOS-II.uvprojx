# Keil uVision project uCOS-II.uvprojx, settings and files
target SWM330 (6160000::V6.16::ARMCLANG)
  device: SWM330xG Synwit
  pack: Synwit.SWM32_DFP.2.2.7
  cpu: CPUTYPE("Cortex-M33") DSP CLOCK(12000000) ESEL ELITTLE
  output: uCOS-II
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 v6Lang=3 v6LangP=1 wLevel=3
  c include: ..\..\SWM330_StdPeriph_Driver\CSL\CMSIS\CoreSupport;..\..\SWM330_StdPeriph_Driver\CSL\CMSIS\DeviceSupport;..\..\SWM330_StdPeriph_Driver\CSL\SWM330_StdPeriph_Driver;.\APP;.\APP\uCOS;.\APP\uCOS\Ports\ARMv7-M\GNU
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group APP
    ./app/: main.c
  group uCOS
    ./APP/uCOS/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS\Port
    ./APP/uCOS/Ports/ARMv7-M/: os_cpu_c.c
    ./APP/uCOS/Ports/ARMv7-M/GNU/: os_cpu_a.S
  group CSL\StdPD
    ../../SWM330_StdPeriph_Driver/CSL/SWM330_StdPeriph_Driver/: SWM330_adc.c SWM330_exti.c SWM330_gpio.c SWM330_i2c.c SWM330_pwm.c SWM330_timr.c SWM330_uart.c SWM330_wdt.c SWM330_dma.c SWM330_flash.c SWM330_port.c SWM330_spi.c SWM330_can.c SWM330_crc.c SWM330_lcd.c SWM330_rtc.c
  group CSL\CMSIS
    ../../SWM330_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/: system_SWM330.c
    ../../SWM330_StdPeriph_Driver/CSL/CMSIS/DeviceSupport/startup/arm/: startup_SWM330.s
